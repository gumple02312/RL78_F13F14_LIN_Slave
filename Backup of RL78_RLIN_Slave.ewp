# IAR project Backup of RL78_RLIN_Slave.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10PPJ RL78 - R5F10PPJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f10ppj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group src
    src/: RLIN_cgc.c RLIN_cgc_user.c RLIN_driver.c RLIN_driver_user.c RLIN_main.c RLIN_port.c RLIN_systeminit.c RLIN_timer.c RLIN_timer_user.c RLIN_wdt.c
